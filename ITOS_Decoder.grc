options:
  parameters:
    author: RAD750 and Ryzerth  MODIFIED BY D8Z
    description: A decoder for analog ITOS HRPT
    generate_options: qt_gui
    id: ITOS_Decoder
    output_language: python
    title: ITOS HRPT Decoder    MODIFIED BY D8Z
  states: {}

blocks:
- name: samples_per_line
  id: variable_qtgui_entry
  parameters:
    comment: Adjust if the image is slanted until it is straight
    label: Samples per line
    type: int
    value: '13107'
  states: {}
- name: wav_samp_rate_mhz
  id: variable
  parameters:
    comment: The input file sample rate, in MHz (e.g. 4 for 4 MHz)
    value: '3'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi/2
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi/2
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-99e3'
    sample_rate: 1e6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: wav_samp_rate_mhz*1000000
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cohen/Downloads/NOAA2_HRPT.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: Subcarrier FFT
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: wav_samp_rate_mhz*1000000
    fc: '0'
    fftsize: '32768'
    name: Carrier FFT
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    name: Raster
    ncols: samples_per_line
    nrows: '256'
    samp_rate: 60e3
    type: float
    update_time: samples_per_line/60000.0
    zmax: '5'
    zmin: '-5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Video Signal
    size: samples_per_line
    srate: 60e3
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '6'
    type: ccc
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_1, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_raster_sink_x_0, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_correctiq_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_correctiq_0, '0']
- [blocks_float_to_complex_1, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
